Commit message: stable position control

File: urdf/ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 19 links, 18 joints
Links:
- added link world
Joints:
- added joint world_arm_joint: type fixed, parent world, child base_link, origin xyz=0 0 0 rpy=0.0 0.0 0
